$ Spice netlist generated by v2lvs
$ v2011.1_15.11    Thu Feb 10 17:20:50 PST 2011
.INCLUDE "/Cad/DesignK/FaradayUMC180/DigitalCore/BackEnd/lvs/fsa0a_c_generic_core.spi"

.SUBCKT SARSlowVerilog Clock Reset Inc Dcr Compare ClockCmp StateP[1] StateP[0]
+ SAROut[7] SAROut[6] SAROut[5] SAROut[4] SAROut[3] SAROut[2] SAROut[1]
+ SAROut[0]
Xg2206 N158 N168 INV1S
Xg2207 N157 N169 INV1S
Xg2205 N156 N171 INV1S
Xg2204 N155 N181 INV1S
Xg2208 N154 N170 INV1S
Xg2209 N182 StateP[1] StateP[0] NR2
Xg2463 SAROut[0] Reset N153 NR2
Xg2464 N184 N153 INV1S
Xg2465 N153 SAR[0] TempSAR[0] NR2
XSAR_reg[0] SAR[0] N152 Clock N12 QDFFRBS
Xg2467 N152 N162 SetSAR[0] SAR[1] StateP[1] AO22
Xg2469 N162 N167 N165 N185 AN3
Xg2470 SAROut[4] N171 N12 AN2
Xg2471 SAROut[7] N168 N12 AN2
Xg2472 SAROut[6] N169 N12 AN2
Xg2473 SAROut[3] N172 N12 AN2
Xg2474 SAROut[5] N170 N12 AN2
Xg2475 SAROut[2] N181 N12 AN2
Xg2476 SAROut[1] N183 N12 AN2
Xg2477 N167 N186 N187 OR2
Xg2478 ClockCmp Clock N182 Reset NR3
Xg2479 N185 CheckID[0] Compare CheckID[0] Compare MOAI1S
Xg2480 N186 CheckID[0] N150 NR2
Xg2481 N187 N150 CheckID[0] AN2
Xg2483 N183 TempSAR[1] SAR[1] OR2
Xg2484 N170 TempSAR[5] SAR[5] OR2
Xg2485 N171 TempSAR[4] SAR[4] OR2
Xg2486 N168 TempSAR[7] SAR[7] OR2
Xg2487 N172 TempSAR[3] SAR[3] OR2
Xg2488 N169 TempSAR[6] SAR[6] OR2
Xg2489 N181 TempSAR[2] SAR[2] OR2
Xg2490 N12 Reset INV1S
Xg2 N165 StateP[0] StateP[1] AN2B1S
Xg4010 N149 N28 N124 N145 N1 N62 N158 OAI222S
XStateP_reg[1] StateP[1] 1000 N147 Clock N12 DFFSBN
Xg4014 N148 N14 N144 N114 N28 N62 N157 OAI222S
XSetSAR_reg[7] SetSAR[7] N143 Clock N12 QDFFRBN
Xg4017 N147 N132 N140 N198 ND3
Xg4018 N146 N0 N139 N104 N28 N62 N154 OAI222S
Xg4019 N145 N136 N138 Compare SetSAR[6] AOI112S
XSetSAR_reg[5] SetSAR[5] N135 Clock N12 QDFFRBN
Xg4023 N144 N138 N115 N116 N8 AOI13HS
Xg4024 N143 N128 N129 N19 ND3
Xg4025 N142 N4 N131 N90 N28 N62 N156 OAI222S
XSetSAR_reg[6] SetSAR[6] N127 Clock N12 QDFFRBN
XTempSAR_reg[1] TempSAR[1] N134 Clock N12 QDFFRBN
Xg4028 N141 N133 N78 N74 N28 OAI112S
Xg4029 N140 N165 N118 N44 OAI12S
Xg4030 N139 N130 N105 N106 Compare OA13S
Xg4031 N138 N130 N76 ND2
Xg4032 N137 N9 N117 N59 N28 N62 N155 OAI222S
Xg4033 N136 N126 N8 N116 SetSAR[6] OA112
Xg4034 N135 N108 N123 N31 ND3
XSetSAR_reg[3] SetSAR[3] N120 Clock N12 QDFFRBN
XSetSAR_reg[4] SetSAR[4] N122 Clock N12 QDFFRBN
Xg4037 N134 N183 N63 N112 TempSAR[1] N25 N29 AO222
Xg4038 N133 TempSAR[3] N110 N101 OAI12S
Xg4039 N132 N8 N1 N124 OR3
Xg4040 N131 N121 N92 N87 N8 AOI13HS
Xg4041 N130 N121 Compare SetSAR[4] AOI12S
Xg4042 N129 N125 N16 TempSAR[7] ND3
Xg4043 N128 TempSAR[7] N18 N124 OR3
Xg4044 N127 N119 N99 N32 ND3
XStateP_reg[0] StateP[0] 1001 N113 Clock N12 DFFSBN
XSetSAR_reg[0] SetSAR[0] N107 Clock N12 QDFFRBN
XSetSAR_reg[2] SetSAR[2] N109 Clock N12 QDFFRBN
Xg4049 N126 N125 INV1S
Xg4050 N125 TempSAR[6] N115 NR2
Xg4051 N124 N14 N114 OR2
Xg4052 N123 N105 N16 TempSAR[5] ND3
Xg4053 N122 N85 N96 N39 ND3
Xg4054 N121 N110 Compare SetSAR[3] AO12
Xg4055 N120 N95 N100 N35 ND3
Xg4056 N119 TempSAR[6] N46 N114 OR3
Xg4057 N118 Compare N192 N186 N8 OAI22S
Xg4058 N117 N103 N97 N26 N65 AOI112S
XSetSAR_reg[1] SetSAR[1] N102 Clock N12 QDFFRBN
Xg4060 N116 SetSAR[5] N106 OR2B1S
Xg4061 N115 N105 N0 ND2
Xg4062 N114 N0 N104 OR2
Xg4063 N113 N94 N199 N13 OAI12S
Xg4064 N112 N97 N93 OR2
Xg4065 N111 N201 N82 N24 N167 OAI112S
Xg4066 N110 N97 N66 Compare AO12
Xg4067 N109 N70 N86 N21 ND3
Xg4068 N108 TempSAR[5] N18 N104 OR3
Xg4069 N107 N84 N6 N162 SetSAR[0] MOAI1S
Xg4072 N106 SetSAR[4] N87 NR2
Xg4073 N105 TempSAR[4] N92 NR2
Xg4074 N104 N4 N90 OR2
Xg4075 N103 N40 N194 NR2
Xg4076 N102 N69 N20 N17 N49 OAI112S
Xg4077 N101 N77 N193 NR2
Xg4078 N100 N16 N77 TempSAR[3] ND3
Xg4079 N99 N47 N71 TempSAR[6] ND3
Xg4082 N96 TempSAR[4] N46 N90 OR3
Xg4083 N95 TempSAR[3] N74 N18 OR3
Xg4084 N94 N91 Reset N13 N54 AOI112S
Xg4085 N93 N67 Compare Compare SetSAR[0] MOAI1S
XSAR_reg[7] SAR[7] N75 Clock N12 QDFFRBN
Xg4087 N92 N77 N11 ND2
Xg4088 N91 SAR[5] SAR[7] N64 SAR[6] SAR[4] N45 NR6
Xg4089 N90 N11 N74 OR2
Xg4092 N87 SetSAR[3] N66 N2 OR3
Xg4093 N86 TempSAR[2] N59 N46 OR3
Xg4094 N85 N47 N51 TempSAR[4] ND3
Xg4095 N84 N48 N3 N25 CheckID[0] AOI13HS
Xg4097 N82 N63 N184 N200 TempSAR[0] AOI22S
Xg4098 N81 N64 N150 N182 Inc MOAI1S
Xg4100 N79 N64 N7 N182 Dcr MOAI1S
XSAR_reg[4] SAR[4] N58 Clock N12 QDFFRBN
XSAR_reg[5] SAR[5] N57 Clock N12 QDFFRBN
XSAR_reg[6] SAR[6] N56 Clock N12 QDFFRBN
XSAR_reg[3] SAR[3] N52 Clock N12 QDFFRBN
XSAR_reg[1] SAR[1] N53 Clock N12 QDFFRBN
XSAR_reg[2] SAR[2] N55 Clock N12 QDFFRBN
Xg4107 N78 N172 N63 ND2S
Xg4108 N77 TempSAR[2] N65 NR2
Xg4109 N76 Compare SetSAR[5] ND2
Xg4110 N75 SetSAR[7] N185 N165 N6 AN4B1S
Xg4111 N74 N9 N59 OR2
Xg4114 N71 N51 N4 N0 AN3
Xg4115 N70 N47 N38 TempSAR[2] ND3
Xg4116 N69 TempSAR[1] N24 N18 OR3
Xg4118 N67 N30 N10 N187 TempSAR[0] AOI22S
Xg4119 N66 SetSAR[2] N40 OR2B1S
Xg4120 N65 N187 N38 ND2
Xg4121 N64 N43 N165 NR2
Xg4122 N62 N63 INV1S
Xg4123 N63 N43 Compare AN2
Xg4126 N59 N25 TempSAR[1] ND2
Xg4127 N58 N39 N37 ND2
Xg4128 N57 N31 N41 ND2
Xg4129 N56 N32 N34 ND2
Xg4130 N55 N21 N42 ND2
Xg4131 N54 N23 StateP[1] NR2
Xg4132 N53 N20 N27 ND2
Xg4133 N52 N35 N36 ND2
Xg4134 N51 N38 N11 N9 AN3
Xg4136 N49 N187 N15 TempSAR[1] ND3
Xg4137 N48 CheckID[0] TempSAR[0] N17 NR3
Xg4138 N47 CheckID[1] N7 N17 NR3
Xg4139 N46 N3 N7 CheckID[1] ND3
Xg4140 N45 SAR[1] N33 SAR[0] OR3B2
Xg4141 N44 N187 N8 N10 Compare AOI22S
Xg4142 N43 StateP[1] StateP[0] AN2B1S
Xg4143 N42 SAR[3] StateP[1] ND2S
Xg4144 N41 SAR[6] StateP[1] ND2S
Xg4145 N40 SetSAR[0] SetSAR[1] NR2
Xg4146 N39 N162 SetSAR[4] ND2S
Xg4147 N38 TempSAR[0] TempSAR[1] NR2
Xg4148 N37 SAR[5] StateP[1] ND2S
Xg4149 N36 SAR[4] StateP[1] ND2S
Xg4150 N35 N162 SetSAR[3] ND2S
Xg4151 N34 SAR[7] StateP[1] ND2S
Xg4152 N33 SAR[2] SAR[3] NR2
Xg4153 N32 N162 SetSAR[6] ND2S
Xg4154 N31 N162 SetSAR[5] ND2S
Xg4155 N30 SetSAR[0] N2 OR2
Xg4156 N28 N29 INV1S
Xg4157 N29 N8 N2 NR2
Xg4158 N27 SAR[2] StateP[1] ND2S
Xg4159 N26 Compare N186 NR2
Xg4160 N24 N25 INV1S
Xg4161 N25 N15 N13 NR2
Xg4162 N23 Dcr Inc NR2
Xg4164 N21 N162 SetSAR[2] ND2S
Xg4165 N20 N162 SetSAR[1] ND2S
Xg4166 N19 N162 SetSAR[7] ND2S
Xg4167 N18 N3 N186 ND2
Xg4168 N16 N17 INV1S
Xg4169 N17 N3 N165 ND2
Xg4186 N13 N165 INV1S
Xg4202 N10 N187 INV1S
Xg4212 N8 Compare INV1S
Xg4217 N6 N167 INV1S
Xg4234 N3 N162 INV1S
Xg4235 N2 N186 INV1S
Xg4257 N192 N71 N1 N14 ND3
Xg4258 N193 N26 N66 NR2
Xg4259 N194 Compare N65 NR2
Xg4261 N97 N165 N8 N187 OAI12S
Xg4262 N197 N165 N6 N185 OA12S
Xg4263 N198 Reset N43 NR2
Xg4264 N199 N44 N26 AN2B1S
Xg4265 N200 N182 StateP[1] OR2
XCheckID_reg[1] CheckID[1] N150 N81 Clock N12 DFFRBN
XTempSAR_reg[0] TempSAR[0] N15 N111 Clock N12 DFFRBN
XTempSAR_reg[6] TempSAR[6] N14 N148 Clock N12 DFFRBN
XTempSAR_reg[3] TempSAR[3] N11 N141 Clock N12 DFFRBN
XTempSAR_reg[2] TempSAR[2] N9 N137 Clock N12 DFFRBN
XCheckID_reg[0] CheckID[0] N7 N79 Clock N12 DFFRBN
XTempSAR_reg[4] TempSAR[4] N4 N142 Clock N12 DFFRBN
XTempSAR_reg[7] TempSAR[7] N1 N149 Clock N12 DFFRBN
XTempSAR_reg[5] TempSAR[5] N0 N146 Clock N12 DFFRBN
Xg4284 N201 N197 StateP[0] Compare OR3B2
.ENDS
.GLOBAL VCC
.GLOBAL GND
