$ Spice netlist generated by v2lvs
$ v2011.1_15.11    Thu Feb 10 17:20:50 PST 2011
.INCLUDE "/Cad/DesignK/FaradayUMC180/DigitalCore/BackEnd/lvs/fsa0a_c_generic_core.spi"

.SUBCKT SARSlowVerilog Clock Reset Inc Dcr Compare ClockCmp StateP[1] StateP[0]
+ SAROut[7] SAROut[6] SAROut[5] SAROut[4] SAROut[3] SAROut[2] SAROut[1]
+ SAROut[0]
Xg2206 INV1S $PINS I=N168 O=N158
Xg2207 INV1S $PINS I=N169 O=N157
Xg2205 INV1S $PINS I=N171 O=N156
Xg2204 INV1S $PINS I=N181 O=N155
Xg2208 INV1S $PINS I=N170 O=N154
Xg2209 NR2 $PINS I1=StateP[1] I2=StateP[0] O=N182
Xg2463 NR2 $PINS I1=Reset I2=N153 O=SAROut[0]
Xg2464 INV1S $PINS I=N153 O=N184
Xg2465 NR2 $PINS I1=SAR[0] I2=TempSAR[0] O=N153
XSAR_reg[0] QDFFRBS $PINS RB=N12 CK=Clock D=N152 Q=SAR[0]
Xg2467 AO22 $PINS A1=N162 A2=SetSAR[0] B1=SAR[1] B2=StateP[1] O=N152
Xg2469 AN3 $PINS I1=N167 I2=N165 I3=N185 O=N162
Xg2470 AN2 $PINS I1=N171 I2=N12 O=SAROut[4]
Xg2471 AN2 $PINS I1=N168 I2=N12 O=SAROut[7]
Xg2472 AN2 $PINS I1=N169 I2=N12 O=SAROut[6]
Xg2473 AN2 $PINS I1=N172 I2=N12 O=SAROut[3]
Xg2474 AN2 $PINS I1=N170 I2=N12 O=SAROut[5]
Xg2475 AN2 $PINS I1=N181 I2=N12 O=SAROut[2]
Xg2476 AN2 $PINS I1=N183 I2=N12 O=SAROut[1]
Xg2477 OR2 $PINS I1=N186 I2=N187 O=N167
Xg2478 NR3 $PINS I1=Clock I2=N182 I3=Reset O=ClockCmp
Xg2479 MOAI1S $PINS A1=CheckID[0] A2=Compare B1=CheckID[0] B2=Compare O=N185
Xg2480 NR2 $PINS I1=CheckID[0] I2=N150 O=N186
Xg2481 AN2 $PINS I1=N150 I2=CheckID[0] O=N187
Xg2483 OR2 $PINS I1=TempSAR[1] I2=SAR[1] O=N183
Xg2484 OR2 $PINS I1=TempSAR[5] I2=SAR[5] O=N170
Xg2485 OR2 $PINS I1=TempSAR[4] I2=SAR[4] O=N171
Xg2486 OR2 $PINS I1=TempSAR[7] I2=SAR[7] O=N168
Xg2487 OR2 $PINS I1=TempSAR[3] I2=SAR[3] O=N172
Xg2488 OR2 $PINS I1=TempSAR[6] I2=SAR[6] O=N169
Xg2489 OR2 $PINS I1=TempSAR[2] I2=SAR[2] O=N181
Xg2490 INV1S $PINS I=Reset O=N12
Xg2 AN2B1S $PINS I1=StateP[0] B1=StateP[1] O=N165
Xg4010 OAI222S $PINS A1=N28 A2=N124 B1=N145 B2=N1 C1=N62 C2=N158 O=N149
XStateP_reg[1] DFFSBN $PINS SB=N12 CK=Clock D=N147 Q=StateP[1]
Xg4014 OAI222S $PINS A1=N14 A2=N144 B1=N114 B2=N28 C1=N62 C2=N157 O=N148
XSetSAR_reg[7] QDFFRBN $PINS RB=N12 CK=Clock D=N143 Q=SetSAR[7]
Xg4017 ND3 $PINS I1=N132 I2=N140 I3=N198 O=N147
Xg4018 OAI222S $PINS A1=N0 A2=N139 B1=N104 B2=N28 C1=N62 C2=N154 O=N146
Xg4019 AOI112S $PINS A1=N136 B1=N138 C1=Compare C2=SetSAR[6] O=N145
XSetSAR_reg[5] QDFFRBN $PINS RB=N12 CK=Clock D=N135 Q=SetSAR[5]
Xg4023 AOI13HS $PINS A1=N138 B1=N115 B2=N116 B3=N8 O=N144
Xg4024 ND3 $PINS I1=N128 I2=N129 I3=N19 O=N143
Xg4025 OAI222S $PINS A1=N4 A2=N131 B1=N90 B2=N28 C1=N62 C2=N156 O=N142
XSetSAR_reg[6] QDFFRBN $PINS RB=N12 CK=Clock D=N127 Q=SetSAR[6]
XTempSAR_reg[1] QDFFRBN $PINS RB=N12 CK=Clock D=N134 Q=TempSAR[1]
Xg4028 OAI112S $PINS A1=N133 B1=N78 C1=N74 C2=N28 O=N141
Xg4029 OAI12S $PINS A1=N165 B1=N118 B2=N44 O=N140
Xg4030 OA13S $PINS A1=N130 B1=N105 B2=N106 B3=Compare O=N139
Xg4031 ND2 $PINS I1=N130 I2=N76 O=N138
Xg4032 OAI222S $PINS A1=N9 A2=N117 B1=N59 B2=N28 C1=N62 C2=N155 O=N137
Xg4033 OA112 $PINS A1=N126 B1=N8 C1=N116 C2=SetSAR[6] O=N136
Xg4034 ND3 $PINS I1=N108 I2=N123 I3=N31 O=N135
XSetSAR_reg[3] QDFFRBN $PINS RB=N12 CK=Clock D=N120 Q=SetSAR[3]
XSetSAR_reg[4] QDFFRBN $PINS RB=N12 CK=Clock D=N122 Q=SetSAR[4]
Xg4037 AO222 $PINS A1=N183 A2=N63 B1=N112 B2=TempSAR[1] C1=N25 C2=N29 O=N134
Xg4038 OAI12S $PINS A1=TempSAR[3] B1=N110 B2=N101 O=N133
Xg4039 OR3 $PINS I1=N8 I2=N1 I3=N124 O=N132
Xg4040 AOI13HS $PINS A1=N121 B1=N92 B2=N87 B3=N8 O=N131
Xg4041 AOI12S $PINS A1=N121 B1=Compare B2=SetSAR[4] O=N130
Xg4042 ND3 $PINS I1=N125 I2=N16 I3=TempSAR[7] O=N129
Xg4043 OR3 $PINS I1=TempSAR[7] I2=N18 I3=N124 O=N128
Xg4044 ND3 $PINS I1=N119 I2=N99 I3=N32 O=N127
XStateP_reg[0] DFFSBN $PINS SB=N12 CK=Clock D=N113 Q=StateP[0]
XSetSAR_reg[0] QDFFRBN $PINS RB=N12 CK=Clock D=N107 Q=SetSAR[0]
XSetSAR_reg[2] QDFFRBN $PINS RB=N12 CK=Clock D=N109 Q=SetSAR[2]
Xg4049 INV1S $PINS I=N125 O=N126
Xg4050 NR2 $PINS I1=TempSAR[6] I2=N115 O=N125
Xg4051 OR2 $PINS I1=N14 I2=N114 O=N124
Xg4052 ND3 $PINS I1=N105 I2=N16 I3=TempSAR[5] O=N123
Xg4053 ND3 $PINS I1=N85 I2=N96 I3=N39 O=N122
Xg4054 AO12 $PINS A1=N110 B1=Compare B2=SetSAR[3] O=N121
Xg4055 ND3 $PINS I1=N95 I2=N100 I3=N35 O=N120
Xg4056 OR3 $PINS I1=TempSAR[6] I2=N46 I3=N114 O=N119
Xg4057 OAI22S $PINS A1=Compare A2=N192 B1=N186 B2=N8 O=N118
Xg4058 AOI112S $PINS A1=N103 B1=N97 C1=N26 C2=N65 O=N117
XSetSAR_reg[1] QDFFRBN $PINS RB=N12 CK=Clock D=N102 Q=SetSAR[1]
Xg4060 OR2B1S $PINS I1=SetSAR[5] B1=N106 O=N116
Xg4061 ND2 $PINS I1=N105 I2=N0 O=N115
Xg4062 OR2 $PINS I1=N0 I2=N104 O=N114
Xg4063 OAI12S $PINS A1=N94 B1=N199 B2=N13 O=N113
Xg4064 OR2 $PINS I1=N97 I2=N93 O=N112
Xg4065 OAI112S $PINS A1=N201 B1=N82 C1=N24 C2=N167 O=N111
Xg4066 AO12 $PINS A1=N97 B1=N66 B2=Compare O=N110
Xg4067 ND3 $PINS I1=N70 I2=N86 I3=N21 O=N109
Xg4068 OR3 $PINS I1=TempSAR[5] I2=N18 I3=N104 O=N108
Xg4069 MOAI1S $PINS A1=N84 A2=N6 B1=N162 B2=SetSAR[0] O=N107
Xg4072 NR2 $PINS I1=SetSAR[4] I2=N87 O=N106
Xg4073 NR2 $PINS I1=TempSAR[4] I2=N92 O=N105
Xg4074 OR2 $PINS I1=N4 I2=N90 O=N104
Xg4075 NR2 $PINS I1=N40 I2=N194 O=N103
Xg4076 OAI112S $PINS A1=N69 B1=N20 C1=N17 C2=N49 O=N102
Xg4077 NR2 $PINS I1=N77 I2=N193 O=N101
Xg4078 ND3 $PINS I1=N16 I2=N77 I3=TempSAR[3] O=N100
Xg4079 ND3 $PINS I1=N47 I2=N71 I3=TempSAR[6] O=N99
Xg4082 OR3 $PINS I1=TempSAR[4] I2=N46 I3=N90 O=N96
Xg4083 OR3 $PINS I1=TempSAR[3] I2=N74 I3=N18 O=N95
Xg4084 AOI112S $PINS A1=N91 B1=Reset C1=N13 C2=N54 O=N94
Xg4085 MOAI1S $PINS A1=N67 A2=Compare B1=Compare B2=SetSAR[0] O=N93
XSAR_reg[7] QDFFRBN $PINS RB=N12 CK=Clock D=N75 Q=SAR[7]
Xg4087 ND2 $PINS I1=N77 I2=N11 O=N92
Xg4088 NR6 $PINS I1=SAR[5] I2=SAR[7] I3=N64 I4=SAR[6] I5=SAR[4] I6=N45 O=N91
Xg4089 OR2 $PINS I1=N11 I2=N74 O=N90
Xg4092 OR3 $PINS I1=SetSAR[3] I2=N66 I3=N2 O=N87
Xg4093 OR3 $PINS I1=TempSAR[2] I2=N59 I3=N46 O=N86
Xg4094 ND3 $PINS I1=N47 I2=N51 I3=TempSAR[4] O=N85
Xg4095 AOI13HS $PINS A1=N48 B1=N3 B2=N25 B3=CheckID[0] O=N84
Xg4097 AOI22S $PINS A1=N63 A2=N184 B1=N200 B2=TempSAR[0] O=N82
Xg4098 MOAI1S $PINS A1=N64 A2=N150 B1=N182 B2=Inc O=N81
Xg4100 MOAI1S $PINS A1=N64 A2=N7 B1=N182 B2=Dcr O=N79
XSAR_reg[4] QDFFRBN $PINS RB=N12 CK=Clock D=N58 Q=SAR[4]
XSAR_reg[5] QDFFRBN $PINS RB=N12 CK=Clock D=N57 Q=SAR[5]
XSAR_reg[6] QDFFRBN $PINS RB=N12 CK=Clock D=N56 Q=SAR[6]
XSAR_reg[3] QDFFRBN $PINS RB=N12 CK=Clock D=N52 Q=SAR[3]
XSAR_reg[1] QDFFRBN $PINS RB=N12 CK=Clock D=N53 Q=SAR[1]
XSAR_reg[2] QDFFRBN $PINS RB=N12 CK=Clock D=N55 Q=SAR[2]
Xg4107 ND2S $PINS I1=N172 I2=N63 O=N78
Xg4108 NR2 $PINS I1=TempSAR[2] I2=N65 O=N77
Xg4109 ND2 $PINS I1=Compare I2=SetSAR[5] O=N76
Xg4110 AN4B1S $PINS I1=SetSAR[7] I2=N185 I3=N165 B1=N6 O=N75
Xg4111 OR2 $PINS I1=N9 I2=N59 O=N74
Xg4114 AN3 $PINS I1=N51 I2=N4 I3=N0 O=N71
Xg4115 ND3 $PINS I1=N47 I2=N38 I3=TempSAR[2] O=N70
Xg4116 OR3 $PINS I1=TempSAR[1] I2=N24 I3=N18 O=N69
Xg4118 AOI22S $PINS A1=N30 A2=N10 B1=N187 B2=TempSAR[0] O=N67
Xg4119 OR2B1S $PINS I1=SetSAR[2] B1=N40 O=N66
Xg4120 ND2 $PINS I1=N187 I2=N38 O=N65
Xg4121 NR2 $PINS I1=N43 I2=N165 O=N64
Xg4122 INV1S $PINS I=N63 O=N62
Xg4123 AN2 $PINS I1=N43 I2=Compare O=N63
Xg4126 ND2 $PINS I1=N25 I2=TempSAR[1] O=N59
Xg4127 ND2 $PINS I1=N39 I2=N37 O=N58
Xg4128 ND2 $PINS I1=N31 I2=N41 O=N57
Xg4129 ND2 $PINS I1=N32 I2=N34 O=N56
Xg4130 ND2 $PINS I1=N21 I2=N42 O=N55
Xg4131 NR2 $PINS I1=N23 I2=StateP[1] O=N54
Xg4132 ND2 $PINS I1=N20 I2=N27 O=N53
Xg4133 ND2 $PINS I1=N35 I2=N36 O=N52
Xg4134 AN3 $PINS I1=N38 I2=N11 I3=N9 O=N51
Xg4136 ND3 $PINS I1=N187 I2=N15 I3=TempSAR[1] O=N49
Xg4137 NR3 $PINS I1=CheckID[0] I2=TempSAR[0] I3=N17 O=N48
Xg4138 NR3 $PINS I1=CheckID[1] I2=N7 I3=N17 O=N47
Xg4139 ND3 $PINS I1=N3 I2=N7 I3=CheckID[1] O=N46
Xg4140 OR3B2 $PINS I1=SAR[1] B1=N33 B2=SAR[0] O=N45
Xg4141 AOI22S $PINS A1=N187 A2=N8 B1=N10 B2=Compare O=N44
Xg4142 AN2B1S $PINS I1=StateP[1] B1=StateP[0] O=N43
Xg4143 ND2S $PINS I1=SAR[3] I2=StateP[1] O=N42
Xg4144 ND2S $PINS I1=SAR[6] I2=StateP[1] O=N41
Xg4145 NR2 $PINS I1=SetSAR[0] I2=SetSAR[1] O=N40
Xg4146 ND2S $PINS I1=N162 I2=SetSAR[4] O=N39
Xg4147 NR2 $PINS I1=TempSAR[0] I2=TempSAR[1] O=N38
Xg4148 ND2S $PINS I1=SAR[5] I2=StateP[1] O=N37
Xg4149 ND2S $PINS I1=SAR[4] I2=StateP[1] O=N36
Xg4150 ND2S $PINS I1=N162 I2=SetSAR[3] O=N35
Xg4151 ND2S $PINS I1=SAR[7] I2=StateP[1] O=N34
Xg4152 NR2 $PINS I1=SAR[2] I2=SAR[3] O=N33
Xg4153 ND2S $PINS I1=N162 I2=SetSAR[6] O=N32
Xg4154 ND2S $PINS I1=N162 I2=SetSAR[5] O=N31
Xg4155 OR2 $PINS I1=SetSAR[0] I2=N2 O=N30
Xg4156 INV1S $PINS I=N29 O=N28
Xg4157 NR2 $PINS I1=N8 I2=N2 O=N29
Xg4158 ND2S $PINS I1=SAR[2] I2=StateP[1] O=N27
Xg4159 NR2 $PINS I1=Compare I2=N186 O=N26
Xg4160 INV1S $PINS I=N25 O=N24
Xg4161 NR2 $PINS I1=N15 I2=N13 O=N25
Xg4162 NR2 $PINS I1=Dcr I2=Inc O=N23
Xg4164 ND2S $PINS I1=N162 I2=SetSAR[2] O=N21
Xg4165 ND2S $PINS I1=N162 I2=SetSAR[1] O=N20
Xg4166 ND2S $PINS I1=N162 I2=SetSAR[7] O=N19
Xg4167 ND2 $PINS I1=N3 I2=N186 O=N18
Xg4168 INV1S $PINS I=N17 O=N16
Xg4169 ND2 $PINS I1=N3 I2=N165 O=N17
Xg4186 INV1S $PINS I=N165 O=N13
Xg4202 INV1S $PINS I=N187 O=N10
Xg4212 INV1S $PINS I=Compare O=N8
Xg4217 INV1S $PINS I=N167 O=N6
Xg4234 INV1S $PINS I=N162 O=N3
Xg4235 INV1S $PINS I=N186 O=N2
Xg4257 ND3 $PINS I1=N71 I2=N1 I3=N14 O=N192
Xg4258 NR2 $PINS I1=N26 I2=N66 O=N193
Xg4259 NR2 $PINS I1=Compare I2=N65 O=N194
Xg4261 OAI12S $PINS A1=N165 B1=N8 B2=N187 O=N97
Xg4262 OA12S $PINS A1=N165 B1=N6 B2=N185 O=N197
Xg4263 NR2 $PINS I1=Reset I2=N43 O=N198
Xg4264 AN2B1S $PINS I1=N44 B1=N26 O=N199
Xg4265 OR2 $PINS I1=N182 I2=StateP[1] O=N200
XCheckID_reg[1] DFFRBN $PINS RB=N12 CK=Clock D=N81 Q=CheckID[1] QB=N150
XTempSAR_reg[0] DFFRBN $PINS RB=N12 CK=Clock D=N111 Q=TempSAR[0] QB=N15
XTempSAR_reg[6] DFFRBN $PINS RB=N12 CK=Clock D=N148 Q=TempSAR[6] QB=N14
XTempSAR_reg[3] DFFRBN $PINS RB=N12 CK=Clock D=N141 Q=TempSAR[3] QB=N11
XTempSAR_reg[2] DFFRBN $PINS RB=N12 CK=Clock D=N137 Q=TempSAR[2] QB=N9
XCheckID_reg[0] DFFRBN $PINS RB=N12 CK=Clock D=N79 Q=CheckID[0] QB=N7
XTempSAR_reg[4] DFFRBN $PINS RB=N12 CK=Clock D=N142 Q=TempSAR[4] QB=N4
XTempSAR_reg[7] DFFRBN $PINS RB=N12 CK=Clock D=N149 Q=TempSAR[7] QB=N1
XTempSAR_reg[5] DFFRBN $PINS RB=N12 CK=Clock D=N146 Q=TempSAR[5] QB=N0
Xg4284 OR3B2 $PINS I1=N197 B1=StateP[0] B2=Compare O=N201
.ENDS
.GLOBAL VCC
.GLOBAL GND
